# Repository netube99/CH573_KIT

File README.md:

# CH573_KIT
CH573F 开发板

* USB/锂电池供电，最高5.5V输入
* 板载功耗检测端口（默认短路），可检测板工作电压电流
* 串口USB/主从机USB/温度传感器/DEBUG端口

* 拓展电路可通过跳线帽短断路，方便低功耗实验，所有IO均已引出

TODO

* 改善射频传输线设计
* 去掉多余的保险丝

## KiCad design CH573_KIT/CH573_KIT.kicad_pcb

Parts:
AE1: Antenna; CA-C03
C1, C2: 10nF 50V; C_0603_1608Metric
C3, C4, C6: 2.2uF 25V; C_0603_1608Metric
C5: 100nF 50V; C_0603_1608Metric
C7, C8, C11, C13, C14: 10uF 10V; C_0603_1608Metric
C9, C10, C12: 1uF 25V; C_0603_1608Metric
C15, C16: NC; C_0603_1608Metric
D1, D2, D4: MBR0520; D_SOD-123
D3: GLEEN LED; LED_0603_1608Metric
D5: SMFJ6.0; D_SOD-123F
D6: SMF3.3A; D_SOD-123F
F1, F2: 200mA 6V; Fuse_0603_1608Metric
J1: BAT; PinHeader_1x02_P2.54mm_Vertical
J2: 2.54 4P; PinHeader_1x04_P2.54mm_Vertical
J3, J6: Conn_02x06_Odd_Even; PinHeader_2x06_P2.54mm_Vertical
J4: Conn_02x08_Odd_Even; PinHeader_2x08_P2.54mm_Vertical
J5: KF2510-4P; Molex_PicoBlade_53047-0410_1x04_P1.25mm_Vertical
L1: 22uH; L_TDK_NLV25_2.5x2.0mm
L2: NLV25T 10uH; L_TDK_NLV25_2.5x2.0mm
R1, R3: 1M; R_0603_1608Metric
R2, R4: 10k; R_0603_1608Metric
R5, R6: 4.7k; R_0603_1608Metric
R7: NC; R_0603_1608Metric
SW1, SW2: SW_Push; SW_Che_2x4x3.5
U1: CH573F; QFN-28-1EP_4x4mm_P0.4mm_EP2.3x2.3mm
U2: TPS62203; SOT-23-5
U3: XC6206; SOT-23
U4: CH343P; QFN-16-1EP_3x3mm_P0.5mm_EP1.7x1.7mm
U5: AHT21
USB1, USB2: USB_C_Plug_USB2.0; USB_C_Receptacle_HRO_TYPE-C-31-M-12
Y1: Crystal_32MHz; Crystal_SMD_2016-4Pin_2.0x1.6mm

Connections:
+3V3: D6.2 (A2), F2.2, J4.1
+5V: C8.1, D4.2 (A), U3.3 (VCC), U4.9 (VBUS), USB2.A4 (VBUS), USB2.A9 (VBUS), USB2.B4 (VBUS), USB2.B9 (VBUS)
/+3.3V_UART: C9.1, C10.1, C11.1, C12.1, U3.2 (Vout), U4.1 (VIO), U4.3 (VDD5), U4.6 (V3)
/AHT_CLK: J4.13, R6.2, U5.3 (SCL)
/AHT_DIO: J4.11, R5.2, U5.4 (SDA)
/BOOT: C15.1, J3.12, SW1.1, U1.17 (PB22/TMR3/RXD2)
/CH_RX: J4.8, J6.4, U1.6 (PA8/RXD1/AIN12)
/CH_TX: J4.10, J6.3, U1.7 (PA9/TMR0/TXD1/AIN13)
/I2C_CK: J3.5, J4.14, U1.10 (PB13/SCK0_/TXD1_)
/I2C_IO: J3.6, J4.12, U1.11 (PB12/SCS_/RXD1_)
/NRST: C16.1, J3.11, SW2.1, U1.16 (PB23/RST#/TMR0_/TXD2/PWM11)
/PA4: J6.11, U1.23 (PA4/RXD3/AIN0)
/PA5: J6.12, U1.24 (PA5/TXD3/AIN1)
/PA10: J6.6, U1.2 (PA10/X32KI/TMR1)
/PA11: J6.5, U1.1 (PA11/X32KO/TMR2)
/PA12: J6.8, U1.28 (PA12/SCS/PWM4/AIN2)
/PA13: J6.7, U1.27 (PA13/SCK0/PWM5/AIN3)
/PA14: J6.10, U1.26 (PA14/MOSI/TXD0_/AIN4)
/PA15: J6.9, U1.25 (PA15/MISO/RXD0_/AIN5)
/PB4: J3.10, U1.15 (PB4/RXD0/PWM7)
/PB7: J3.9, U1.14 (PB7/TXD0/PWM9)
/PB10: J3.8, J4.4, U1.13 (PB10/UD-/TMR1_)
/PB11: J3.7, J4.6, U1.12 (PB11/UD+/TMR2_)
/PB14: J2.2, J3.4, U1.9 (PB14/TIO/MOSI_/PWM10/DSR)
/PB15: J2.3, J3.3, U1.8 (PB15/TCK/MISO_/DTR)
/USB1_DN: J4.3, USB1.A7 (D-)
/USB1_DP: J4.5, USB1.A6 (D+)
/USB2_DN: U4.8 (UD-), USB2.A7 (D-)
/USB2_DP: U4.7 (UD+), USB2.A6 (D+)
/USB_RX: J4.9, U4.5 (RXD)
/USB_TX: J4.7, U4.4 (TXD)
/VDD_AHT: C14.1, J4.15, R5.1, R6.1, U5.2 (VCC)
/VSW: C5.1, C6.1, L1.2, U1.3 (VDCID), U1.22 (VDCIA)
/X32MI: U1.19 (X32MI), Y1.3
/X32MO: U1.18 (X32MO), Y1.1
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, D3.1 (K), D5.1 (A1), D6.1 (A1), J1.2, J2.4, J5.4, J6.1, J6.2, R1.1, R3.1, SW1.2, SW2.2, U1.29 (GND), U2.2 (GND), U3.1 (VSS), U4.2 (GND), U4.17 (GND), U5.5 (GND), USB1.A1 (GND), USB1.A12 (GND), USB1.B1 (GND), USB1.B12 (GND), USB2.A1 (GND), USB2.A12 (GND), USB2.B1 (GND), USB2.B12 (GND), Y1.2, Y1.4
unnamed: AE1.1 (A), U1.21 (ANT)
unnamed: C1.1, R1.2, USB1.S1 (SHIELD)
unnamed: C2.1, R3.2, USB2.S1 (SHIELD)
unnamed: C4.1, U1.20 (VINTA)
unnamed: C7.1, D5.2 (A2), F1.2, R4.1, U2.1 (VIN)
unnamed: C13.1, F2.1, L2.2, U2.4 (FB)
unnamed: D1.2 (A), J1.1
unnamed: D2.2 (A), USB1.A4 (VBUS), USB1.A9 (VBUS), USB1.B4 (VBUS), USB1.B9 (VBUS)
unnamed: D3.2 (A), R2.2
unnamed: F1.1, J5.2, J5.3, R7.1
unnamed: L1.1, U1.4 (VSW)
unnamed: L2.1, U2.5 (SW)
unnamed: R4.2, U2.3 (EN)
VBUS: D1.1 (K), D2.1 (K), D4.1 (K), J5.1, R2.1, R7.2
VDD: C3.1, J2.1, J3.1, J3.2, J4.2, J4.16, U1.5 (VIO33/VDD33)

Notes on the sheet:
直流电源输入 3.5V MIN 5.5V MAX
3/4 电压测量
(0R)
(100nF 50V)
1/2 电流测量
DEBUG
H/D USB
串口 USB

Board: 2 copper layers, 39.5 x 52.5 mm, 50 parts (1 on the bottom side), 51 nets.

## Commit log

2021-12-18 first
2021-12-31 初步完成原理图
2022-01-05 V1.0
2022-01-23 Create LICENSE
